# Keil uVision project App.uvproj, settings and files
target App_Stand (ARM-ADS)
  device: STM32F100C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: App_Stand
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD_VL
  c include: ..\src;..\drv;..\sys;..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../src/: main.c cmath.c lcr.c
  group drv
    ../drv/: base.h led.c spi_flash.c timebase.c lcd.c skey.c
  group sys
    ../sys/: stm32_it.c system_stm32f10x.c system_stm32f10x_iap.c startup_stm32f10x_md_vl.s
  group STM32F10x_StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_pwr.c
  group Doc
    ../: readme.txt
target App_IAP (ARM-ADS)
  device: STM32F100C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: as above
  output: App_IAP
  AfterMake: F:\Keil\ARM\ARMCC\bin\fromelf.exe --bin -o  ..\update.bin .\out\App_IAP.axf
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD_VL
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
