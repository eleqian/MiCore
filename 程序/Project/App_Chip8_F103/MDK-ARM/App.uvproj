# Keil uVision project App.uvproj, settings and files
target App_Stand (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: App_Stand
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\src;..\chip8;..\fatfs;..\drv;..\sys;..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../src/: main.c
  group drv
    ../drv/: base.h led.c spi_flash.c timebase.c lcd.c skey.c
  group fatfs
    ../fatfs/: diskio.c ff.c ffconf.h
  group chip8
    ../chip8/: file.c input.c schip.c shell.c sound.c
  group sys
    ../sys/: stm32_it.c system_stm32f10x.c system_stm32f10x_iap.c startup_stm32f10x_md.s
  group STM32F10x_StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_pwr.c
  group Doc
    ../: readme.txt
target App_IAP (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: App_IAP
  AfterMake: F:\Keil\ARM\ARMCC\bin\fromelf.exe --bin -o  ..\update.bin .\out\App_IAP.axf
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\src;..\fatfs;..\drv;..\chip8;..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x1c000
  memory RVCT9: RAM 0x20000000 size 0x5000
